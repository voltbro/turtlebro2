Commit message: Add turtlebro2 model

File: urdf/turtlebro2.urdf (robot description, URDF)
Before this commit: robot turtlebro, 7 links, 6 joints
Joints:
- joint camera_joint: origin xyz=0.06 0 0.055 rpy=0 0.47 0 -> xyz=0.06 0 0.055 rpy=-1.98 0 -1.57075
